# Keil uVision project microprocessor_final_project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: microprocessor_final_project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10x_MD_VL
  asm define: STM32F10x_MD_VL
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: boardA_main.c boardA_settingTimer.c boardA_ADC.c boardA_key.c boardA_Timer1.c boardA_USART1.c boardA_usartError.c boardA_flash.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
